# Can't build ACAP due to mongodb, temporarily disable
#
#IMAGE_INSTALL:append:system-controller = " \
#    acap \
#    "
