# acap - disable due to mongodb does not python 3.12
#IMAGE_INSTALL:append:system-controller = " \
#    acap \
#    "

